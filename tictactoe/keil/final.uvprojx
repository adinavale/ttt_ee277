# Keil uVision project final.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code
  AfterMake: fromelf -cvf .\Objects\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\Objects\code.axf -o disasm.txt
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Application;.\Core;.\Device
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ./Application/: main.c
  group Device
    ./Device/: cm0dsasm.s edk_api.c edk_api.h EDK_CM0.h edk_driver.c edk_driver.h retarget.c
  group Core
    ./Core/: core_cm0.h core_cmFunc.h core_cmInstr.h
software components: CMSIS:CORE 5.5.0
